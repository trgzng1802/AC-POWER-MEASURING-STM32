# Keil uVision project Power-Meter.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Power-Meter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group Libs
    ./: rcc_config.c rcc_config.h gpio.c gpio.h lcd_4bit.c lcd_4bit.h adc.c adc.h measure.c measure.h
software components: CMSIS:CORE 5.6.0, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0
